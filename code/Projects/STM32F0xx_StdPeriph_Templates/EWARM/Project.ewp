# IAR project Project.ewp, settings and files
configuration STM32F051 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x4 ST STM32F030x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F051; USE_STM320518_EVAL; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM320518_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F0XX_MD.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f051_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F031 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F031x6 ST STM32F031x6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F031; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc
  OBJCOPY.OOCOutputFile: STM32F0XX_LD.hex
  ILINK.IlinkIcfFile: stm32f031_flash.icf
configuration STM32F072 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F072VB ST STM32F072VB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F072; USE_STM32072B_EVAL; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32072B_EVAL
  ILINK.IlinkIcfFile: stm32f072_flash.icf
configuration STM32F030 (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc; ..\..\source\inc; ..\..\source\ICM42670P\APP\inc; ..\..\source\ICM42670P\IMU\inc
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: test.bin
  ILINK.IlinkIcfFile: stm32f030_flash.icf
configuration STM32F042 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F042x6 ST STM32F042x6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F042; SE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: stm32f042_flash.icf
configuration STM32F091 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F091VC ST STM32F091VC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F091; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: stm32f091_flash.icf
configuration STM32F030xC (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F030RC ST STM32F030RC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030xC; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: stm32f030xc_flash.icf
configuration STM32F070x6 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F070C6 ST STM32F070C6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F070x6; SE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: stm32f070x6_flash.icf
configuration STM32F070xB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F070RB ST STM32F070RB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F070xB; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: stm32f070xb_flash.icf
  group App
    ../../source/ICM42670P/APP/src/: ICM42670P.c
    ../../source/src/: iic_drv.c key.c led.c oled_096.c oled_font.c uart.c ws2812_app.c ws2812_drv.c
  group CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030.s startup_stm32f030xc.s startup_stm32f031.s startup_stm32f042.s startup_stm32f051.s startup_stm32f070x6.s startup_stm32f070xb.s startup_stm32f072.s startup_stm32f091.s
    ../: system_stm32f0xx.c
  group IMU
    ../../source/ICM42670P/IMU/src/: inv_imu_apex.c inv_imu_driver.c inv_imu_selftest.c inv_imu_transport.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ../: main.c stm32f0xx_it.c
